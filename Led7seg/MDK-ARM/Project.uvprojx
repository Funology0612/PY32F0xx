# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: PY32F030x4 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F0xx_HAL_Driver;..\..\Drivers\CMSIS\Include;..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\Drivers\BSP\PY32F030xx_Start_Kit;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F0xx_HAL_Driver;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Common
    ./: startup_py32f030xx.s
    ../../Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c
  group BSP/py32f030xx_Start_Kit
    ../../Drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_Start_Kit.c
  group Doc
    ../: readme.txt
  group D:\CubeMX\PY32F0xx_Firmware_V1.1.3\PY32F0xx\Drivers\PY32F0xx_HAL_Driver
    ../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_uart.c
software components: CMSIS:CORE 6.1.0
